# IAR project CC2540_UART.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC2540F256 CC2540F256
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: APP\Include; BLEStack\Include\Controller; BLEStack\Include\Host; HAL\Include; HAL\Target\CC2540EB\Include; NPI\Include; OSAL\Include; Profile\Devinfo; Profile\Roles; Profile\MineProfile; $PROJ_DIR\BLEStack\Source
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: E:\CC2540_COM\Project\LinkerConfig\ti_51ew_cc2540b.xcl
configuration Release (8051)
  as the first configuration, except:
  General.OGChipSelectMenu: 8052 Generic 8052
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptStrategy: 0
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group APP
    APP/Source/: BLEPeripheral.c BLEPeripheral_Main.c OnBoard.c OSAL_BLEPeripheral.c serialInterface.c
  group APP/Include
    APP/Include/: BLEPeripheral.h OnBoard.h serialInterface.h
  group BLEStack/Include/Controller
    BLEStack/Include/Controller/: hci.h hci_data.h hci_event.h hci_tl.h ll.h ll_math.h ll_sleep.h ll_timer2.h phy.h phy_image.h
  group BLEStack/Include/Host
    BLEStack/Include/Host/: att.h bcomdef.h gap.h gapgattserver.h gatt.h gatt_uuid.h gattservapp.h l2cap.h linkdb.h sm.h
  group BLEStack/Libraries
    BLEStack/Libraries/CC2540DB/: CC2540_BLE.lib CC2540_BLE_peri.lib
    BLEStack/Libraries/Common/: CC254x_BLE_HCI_TL_None.lib
  group HAL/Include
    HAL/Include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Source
    HAL/Source/: hal_assert.c hal_drivers.c
  group HAL/Target/CC2540EB/Include
    HAL/Target/CC2540EB/Include/: hal_aes.h hal_board_cfg.h hal_ccm.h hal_crc.h hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/CC2540EB/Source
    HAL/Target/CC2540EB/Source/: hal_adc.c hal_aes.c hal_crc.c hal_dma.c hal_flash.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group NPI
    NPI/Source/: npi.c
  group NPI/Include
    NPI/Include/: npi.h
  group OSAL/Include
    OSAL/Include/: OSAL.h osal_bufmgr.h osal_cbtimer.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h osal_snv.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
  group OSAL/Source
    OSAL/Source/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c osal_snv.c OSAL_Timers.c
  group ProConfig
    Project/config/: buildComponents.cfg buildConfig.cfg
  group Profiles/Include
    Profile/DevInfo/: devinfoservice.h
    Profile/Roles/: gapbondmgr.h
    Profile/MineProfile/: MineGATTprofile.h
    Profile/Roles/CC254x/: peripheral.h
  group Profiles/Source
    Profile/DevInfo/: devinfoservice.c
    Profile/Roles/: gap.c gapbondmgr.c gatt_uuid.c peripheral.c
    Profile/GATT/: gattservapp_util.c
    Profile/MineProfile/: MineGATTprofile.c
