<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CC2540_Central.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\CC2540_UART.ewp</path>
  </project>
  <batchBuild/>
</workspace>


