<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>4</parallelThreads>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
          <analyzeTimeout>600</analyzeTimeout>
          <enableParallel>0</enableParallel>
          <parallelThreads>4</parallelThreads>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <group>
    <name>APP</name>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\APP\Include\BLEPeripheral.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\APP\Include\OnBoard.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\APP\Include\serialInterface.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\APP\Source\BLEPeripheral.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\APP\Source\BLEPeripheral_Main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\APP\Source\OnBoard.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\APP\Source\OSAL_BLEPeripheral.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\APP\Source\serialInterface.c</name>
    </file>
  </group>
  <group>
    <name>BLEStack</name>
    <group>
      <name>Include</name>
      <group>
        <name>Controller</name>
        <file>
          <name>$PROJ_DIR$\BLEStack\Include\Controller\hci.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\BLEStack\Include\Controller\hci_data.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\BLEStack\Include\Controller\hci_event.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\BLEStack\Include\Controller\hci_tl.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\BLEStack\Include\Controller\ll.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\BLEStack\Include\Controller\ll_math.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\BLEStack\Include\Controller\ll_sleep.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\BLEStack\Include\Controller\ll_timer2.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\BLEStack\Include\Controller\phy.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\BLEStack\Include\Controller\phy_image.h</name>
        </file>
      </group>
      <group>
        <name>Host</name>
        <file>
          <name>$PROJ_DIR$\BLEStack\Include\Host\att.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\BLEStack\Include\Host\bcomdef.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\BLEStack\Include\Host\gap.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\BLEStack\Include\Host\gapgattserver.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\BLEStack\Include\Host\gatt.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\BLEStack\Include\Host\gatt_uuid.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\BLEStack\Include\Host\gattservapp.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\BLEStack\Include\Host\l2cap.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\BLEStack\Include\Host\linkdb.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\BLEStack\Include\Host\sm.h</name>
        </file>
      </group>
    </group>
    <group>
      <name>Libraries</name>
      <file>
        <name>$PROJ_DIR$\BLEStack\Libraries\CC2540DB\CC2540_BLE.lib</name>
      </file>
      <file>
        <name>$PROJ_DIR$\BLEStack\Libraries\CC2540DB\CC2540_BLE_peri.lib</name>
      </file>
      <file>
        <name>$PROJ_DIR$\BLEStack\Libraries\Common\CC254x_BLE_HCI_TL_None.lib</name>
      </file>
    </group>
  </group>
  <group>
    <name>HAL</name>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\HAL\Include\hal_adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\HAL\Include\hal_assert.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\HAL\Include\hal_board.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\HAL\Include\hal_defs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\HAL\Include\hal_drivers.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\HAL\Include\hal_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\HAL\Include\hal_led.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\HAL\Include\hal_rpc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\HAL\Include\hal_sleep.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\HAL\Include\hal_timer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\HAL\Include\hal_uart.h</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\HAL\Source\hal_assert.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\HAL\Source\hal_drivers.c</name>
      </file>
    </group>
    <group>
      <name>Target</name>
      <group>
        <name>CC2540EB</name>
        <group>
          <name>Include</name>
          <file>
            <name>$PROJ_DIR$\HAL\Target\CC2540EB\Include\hal_aes.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\HAL\Target\CC2540EB\Include\hal_board_cfg.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\HAL\Target\CC2540EB\Include\hal_ccm.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\HAL\Target\CC2540EB\Include\hal_crc.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\HAL\Target\CC2540EB\Include\hal_dma.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\HAL\Target\CC2540EB\Include\hal_mcu.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\HAL\Target\CC2540EB\Include\hal_types.h</name>
          </file>
        </group>
        <group>
          <name>Source</name>
          <file>
            <name>$PROJ_DIR$\HAL\Target\CC2540EB\Source\hal_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\HAL\Target\CC2540EB\Source\hal_aes.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\HAL\Target\CC2540EB\Source\hal_crc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\HAL\Target\CC2540EB\Source\hal_dma.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\HAL\Target\CC2540EB\Source\hal_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\HAL\Target\CC2540EB\Source\hal_led.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\HAL\Target\CC2540EB\Source\hal_sleep.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\HAL\Target\CC2540EB\Source\hal_startup.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\HAL\Target\CC2540EB\Source\hal_timer.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\HAL\Target\CC2540EB\Source\hal_uart.c</name>
          </file>
        </group>
      </group>
    </group>
  </group>
  <group>
    <name>NPI</name>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\NPI\Include\npi.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\NPI\Source\npi.c</name>
    </file>
  </group>
  <group>
    <name>OSAL</name>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\OSAL\Include\OSAL.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\OSAL\Include\osal_bufmgr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\OSAL\Include\osal_cbtimer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\OSAL\Include\OSAL_Clock.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\OSAL\Include\OSAL_Memory.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\OSAL\Include\OSAL_Nv.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\OSAL\Include\OSAL_PwrMgr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\OSAL\Include\osal_snv.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\OSAL\Include\OSAL_Tasks.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\OSAL\Include\OSAL_Timers.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\OSAL\Include\ZComDef.h</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\OSAL\Source\OSAL.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\OSAL\Source\osal_bufmgr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\OSAL\Source\osal_cbtimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\OSAL\Source\OSAL_ClockBLE.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\OSAL\Source\OSAL_Memory.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\OSAL\Source\OSAL_PwrMgr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\OSAL\Source\osal_snv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\OSAL\Source\OSAL_Timers.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>ProConfig</name>
    <file>
      <name>$PROJ_DIR$\Project\config\buildComponents.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Project\config\buildConfig.cfg</name>
    </file>
  </group>
  <group>
    <name>Profiles</name>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\Profile\DevInfo\devinfoservice.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Profile\Roles\gapbondmgr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Profile\MineProfile\MineGATTprofile.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Profile\Roles\CC254x\peripheral.h</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\Profile\DevInfo\devinfoservice.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Profile\Roles\gap.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Profile\Roles\gapbondmgr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Profile\Roles\gatt_uuid.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Profile\GATT\gattservapp_util.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Profile\MineProfile\MineGATTprofile.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Profile\Roles\peripheral.c</name>
      </file>
    </group>
  </group>
</project>


